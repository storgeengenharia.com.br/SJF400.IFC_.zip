Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: SJF400.IFC
Time: 2024-09-09T13:02:14
Written by: SwIFC
Made in: SolidWorks 2023

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Bocal 560mm EBM
In: Default Storey
Material: Liga de aço (SS)

# IfcBuildingElementProxy: Canaleta (3)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Chapa Aleta_Valor predeterminado<Como usinado> (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Corpo
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Haste Aleta (4)
In: Default Storey
Material: Aço galvanizado

# IfcBuildingElementProxy: Prensa Cabo 3.8
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Suporte do Motor
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Suporte para Fixação (2)
In: Default Storey
Material: Steel

# IfcBuildingElementProxy: Tampa
In: Default Storey
Material: Steel
